# IAR project lcdrf.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  group (top)
    ./: lcd.c lcd.h lcd_charset.c lcd_charset.h main_lcdrf.c
  group ti
    ti/: CC1100-CC2500.c CC1100-CC2500.h include.h TI_CC_CC1100-CC2500.h TI_CC_hardware_board_launchpad.h TI_CC_msp430.h TI_CC_spi.c TI_CC_spi.h
